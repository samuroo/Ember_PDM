Commit message: adding mm, and new global_solver

File: global_solver_OLD/assets/hallway_env1.urdf (robot description, URDF)
Before this commit: robot hallway_env, 7 links, 6 joints
Joints:
- joint floor_joint: origin xyz=0 0 -0.05 rpy=0 0 0 -> xyz=0 0 0.05 rpy=0 0 0
